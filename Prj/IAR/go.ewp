# IAR project go.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\Lib\DiskIO; ..\..\Lib; ..\..\Lib\freemaster_driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: go.hex
  ILINK.IlinkOutputFile: go.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: E:\freescale\code\go\Prj\IAR\config files\vcan_ROM_K60N512.icf
  group App
    ../../App/: main.c MK60_it.c parameter.c sensor.c stand.c upper.c
  group Board
    ../../Board/src/: 8700_2100.c I2C.c L3G4200D.c OLED.c VCAN_key.c VCAN_LED.C VCAN_NRF24L0.c
  group Chip
    ../../Chip/src/: misc.c MK60_adc.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../App/: MK60_conf.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group Lib/CMSIS
    ../../Lib/CMSIS/: iar_cortexM4l_math.a iar_cortexM4lf_math.a
  group User
    ../../Board/inc/: 8700_2100.h I2C.h L3G4200D.h MMA8451.h OLED.h
    ../../Chip/inc/: common.h MK60_SysTick.h MK60_uart.h vectors.h
    ../../App/Inc/: include.h MK60_conf.h MK60_it.h parameter.h PORT_cfg.h sensor.h stand.h upper.h
    ../../User/: note_k60.txt
